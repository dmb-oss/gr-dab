options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    run_command: python3 -u {filename}
    run_options: run
  states: {}

blocks:
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: file_out
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: file_in
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: proc_rate
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1504'
    type: byte
  states: {}
- name: dab_ts_packet_align_0
  id: dab_ts_packet_align
  parameters:
    npacks: '8'
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: file_in
  id: parameter
  parameters:
    short_id: i
    type: str
    value: ''
  states: {}
- name: file_out
  id: parameter
  parameters:
    short_id: o
    type: str
    value: ''
  states: {}
- name: proc_rate
  id: parameter
  parameters:
    short_id: s
    type: eng_float
    value: 100e6
  states: {}

connections:
- [blocks_file_source_1, '0', blocks_throttle2_1, '0']
- [blocks_throttle2_1, '0', dab_ts_packet_align_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_file_sink_2, '0']
- [dab_ts_packet_align_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', blocks_vector_to_stream_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
