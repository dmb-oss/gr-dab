options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dmb_rx
    output_language: python
    run_command: python3 -u {filename}
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '['' 7A | 175.280 MHz'', '' 7B | 177.008 MHz'', '' 7C | 178.736 MHz'', '' 8A | 181.280 MHz'', '' 8B | 183.008 MHz'', '' 8C | 184.736 MHz'', '' 9A | 187.280 MHz'', '' 9B | 189.008 MHz'', '' 9C | 190.736 MHz'', ''11A | 199.280 MHz'', ''11B | 201.008 MHz'', ''11C | 202.736 MHz'', ''12A | 205.280 MHz'', ''12B | 207.008 MHz'', ''12C | 208.736 MHz'', ''13A | 211.280 MHz'', ''13B | 213.008 MHz'', ''13C | 214.736 MHz'']'
    num_opts: '0'
    options: '[175.280e6, 177.008e6, 178.736e6, 181.280e6, 183.008e6, 184.736e6, 187.280e6, 189.008e6, 190.736e6, 199.280e6, 201.008e6, 202.736e6, 205.280e6, 207.008e6, 208.736e6, 211.280e6, 213.008e6, 214.736e6]'
    type: real
    value: 205.280e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/dmb/fic.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/dmb/msc.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /tmp/dmb/dmb.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: /tmp/dmb/dmb.raw
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/dmb/dmb.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '32'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1504'
    type: byte
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /tmp/dmb/dmb.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: dab_fic_decode_0
  id: dab_fic_decode
  parameters:
    dab_mode: '1'
    print_channel_info: 'True'
    samp_rate: samp_rate
  states: {}
- name: dab_msc_decode_0
  id: dab_msc_decode
  parameters:
    address: '0'
    dab_mode: '1'
    debug: 'False'
    protection: '6'
    samp_rate: samp_rate
    size: '252'
    verbose: 'True'
  states: {}
- name: dab_ofdm_demod_0
  id: dab_ofdm_demod
  parameters:
    autocorr_sr: 'True'
    correct_ffe: 'True'
    dab_mode: '1'
    eq_mag: 'True'
    input_fft: 'True'
    ppm_error: '0'
    samp_rate: samp_rate
    soft_bits: soft
  states: {}
- name: dab_ts_packet_align_0
  id: dab_ts_packet_align
  parameters:
    npacks: '8'
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: freq
  id: parameter
  parameters:
    short_id: f
    type: eng_float
    value: 205.280e6
  states: {state: disabled}
- name: gain
  id: parameter
  parameters:
    short_id: g
    type: eng_float
    value: '20'
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    short_id: s
    type: intx
    value: '2048000'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', dab_ofdm_demod_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_file_sink_2, '0']
- [blocks_vector_to_stream_1, '0', network_udp_sink_0, '0']
- [blocks_vector_to_stream_2, '0', qtgui_const_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [dab_fic_decode_0, '0', blocks_vector_to_stream_0, '0']
- [dab_msc_decode_0, '0', blocks_file_sink_1, '0']
- [dab_msc_decode_0, '0', dab_ts_packet_align_0, '0']
- [dab_ofdm_demod_0, '0', blocks_vector_to_stream_2, '0']
- [dab_ofdm_demod_0, '0', dab_fic_decode_0, '0']
- [dab_ofdm_demod_0, '0', dab_msc_decode_0, '0']
- [dab_ts_packet_align_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', blocks_vector_to_stream_1, '0']
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_3, '0']
- [soapy_rtlsdr_source_0, '0', dab_ofdm_demod_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
